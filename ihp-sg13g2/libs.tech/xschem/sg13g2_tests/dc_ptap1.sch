** sch_path: ihp-sg13g2/libs.tech/xschem/sg13g2_tests/dc_ptap1.sch
* Copyright 2023 IHP PDK Authors
**.subckt dc_ptap1
Vres Vcc GND 1.5
Vr Vcc net1 0
.save i(vr)
XR1 GND net1 ptap1 R=[ ev { 1.0 / ( 1.0 / ( 9.8e-10 / ( 0.78e-6 * 0.78e-6 ) ) + 1.0 / ( 9.8e-4 / ( 2.0 * ( 0.78e-6 + 0.78e-6 ) ) ) ) }
+ ] w=0.78e-6 l=0.78e-6
**** begin user architecture code



.lib cornerRES.lib res_typ






.param temp=27
.control
save all
op
print Vcc/I(Vr)
reset
dc Vres 0 3 0.01
write dc_ptap1.raw
.endc



**** end user architecture code
**.ends
.GLOBAL GND
.end
