** sch_path: ihp-sg13g2/libs.tech/xschem/sg13g2_tests/tran_logic_not.sch
* Copyright 2023 IHP PDK Authors
**.subckt tran_logic_not
Vin in GND dc 0 ac 0 pulse(0, 1.8, 0, 100p, 100p, 2n, 4n )
Vdd net1 GND 1.8
XM1 GND in out net2 sg13_lv_nmos w=1.0u l=0.45u ng=1 m=1
XR1 net2 GND ptap1 R=[ ev { 1.0 / ( 1.0 / ( 9.8e-10 / ( 0.78e-6 * 0.78e-6 ) ) + 1.0 / ( 9.8e-4 / ( 2.0 * ( 0.78e-6 + 0.78e-6 ) ) ) ) }
+ ] w=0.78e-6 l=0.78e-6
XR2 net1 net3 ntap1 R=262.8 w=0.78e-6 l=0.78e-6
XM2 out in net1 net3 sg13_lv_pmos w=1.0u l=0.45u ng=1 m=1
**** begin user architecture code

.lib $::SG13G2_MODELS/cornerMOSlv.lib mos_tt
.lib $::SG13G2_MODELS/cornerRES.lib res_typ



.param temp=27
.control
pre_osdi ./psp103_nqs.osdi
save all
tran 50p 20n
meas tran tdelay TRIG v(in) VAL=0.9 FALL=1 TARG v(out) VAL=0.9 RISE=1
write ../raw/tran_logic_not.raw
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end
