** sch_path: ihp-sg13g2/libs.tech/xschem/sg13g2_tests/mc_res_op.sch
* Copyright 2023 IHP PDK Authors
**.subckt mc_res_op
Vres Vcc GND 1.5
Vsil Vcc net1 0
.save i(vsil)
Vppd Vcc net2 0
.save i(vppd)
XR3 net3 GND sub! rhigh w=1.0e-6 l=1.0e-6 m=1 b=0
Vrh Vcc net3 0
.save i(vrh)
XR1 GND net1 sub! rsil w=0.5e-6 l=0.5e-5 m=1 b=0
XR2 GND net2 sub! rppd w=0.5e-6 l=0.5e-6 m=1 b=0
Vsil1 Vcc net4 0
.save i(vsil1)
XR4 GND net4 sub! rsil w=0.5e-6 l=0.5e-5 m=1 b=0
Vppd1 Vcc net5 0
.save i(vppd1)
XR5 GND net5 sub! rppd w=0.5e-6 l=0.5e-6 m=1 b=0
XR6 net6 GND sub! rhigh w=1.0e-6 l=1.0e-6 m=1 b=0
Vrh1 Vcc net6 0
.save i(vrh1)
XR7 sub! GND ptap1 R=[ ev { 1.0 / ( 1.0 / ( 9.8e-10 / ( 0.78e-6 * 0.78e-6 ) ) + 1.0 / ( 9.8e-4 / ( 2.0 * ( 0.78e-6 + 0.78e-6 ) ) ) ) }
+ ] w=0.78e-6 l=0.78e-6
**** begin user architecture code

*.lib $::SG13G2_MODELS/cornerRES.lib res_typ
*.lib $::SG13G2_MODELS/cornerRES.lib res_typ_mismatch
*.lib $::SG13G2_MODELS/cornerRES.lib res_typ_stat
.lib $::SG13G2_MODELS/cornerRES.lib res_typ_stat_mismatch



.param temp=27
.control
let mc_runs = 3
let run = 0
set curplot=new
set scratch=$curplot
setplot $scratch
let rsilval=unitvec(mc_runs)
let rsilval1=unitvec(mc_runs)
let rppdval=unitvec(mc_runs)
let rppdval1=unitvec(mc_runs)
let rhighval=unitvec(mc_runs)
let rhighval1=unitvec(mc_runs)

***************** LOOP *********************
dowhile run < mc_runs

op
set run=$&run
set dt=$curplot
setplot $scratch
let out{$run}={$dt}.I(Vsil)
let rsilval[run]= 1.5/{$dt}.I(Vsil)
let rsilval1[run]= 1.5/{$dt}.I(Vsil1)
let rppdval[run]= 1.5/{$dt}.I(Vppd)
let rppdval1[run]= 1.5/{$dt}.I(Vppd1)
let rhighval[run]= 1.5/{$dt}.I(Vrh)
let rhighval1[run]= 1.5/{$dt}.I(Vrh1)
setplot $dt
reset
let run=run+1
end
***************** LOOP *********************

wrdata mc_res_op.csv {$scratch}.rsilval {$scratch}.rsilval1 {$scratch}.rppdval {$scratch}.rppdval1 {$scratch}.rhighval
+ {$scratch}.rhighval1
write mc_res_op.raw
echo
print {$scratch}.rsilval
print {$scratch}.rsilval1
print {$scratch}.rppdval
print {$scratch}.rppdval1
print {$scratch}.rhighval
print {$scratch}.rhighval1
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL sub!
.end
