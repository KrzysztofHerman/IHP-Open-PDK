** sch_path: ihp-sg13g2/libs.tech/xschem/sg13g2_tests/iso_dc_res.sch
* Copyright 2023 IHP PDK Authors
**.subckt iso_dc_res
Vres Vcc Vss 1.2
Vsil Vcc net1 0
.save i(vsil)
Vppd Vcc net2 0
.save i(vppd)
Vrh Vcc net3 0
.save i(vrh)
XR1 Vss net1 iso_B rsil w=1.5e-6 l=10.5e-6 m=1 b=0
XR2 Vss net2 iso_B rppd w=1.5e-6 l=10.5e-6 m=1 b=0
XR3 net3 Vss iso_B rhigh w=1.5e-6 l=10.5e-6 m=1 b=0
XR5 sub! GND ptap1 R=[ ev { 1.0 / ( 1.0 / ( 9.8e-10 / ( 0.78e-6 * 0.78e-6 ) ) + 1.0 / ( 9.8e-4 / ( 2.0 * ( 0.78e-6 + 0.78e-6 ) ) ) ) }
+ ] w=0.78e-6 l=0.78e-6
Vdd net4 GND 1.2
XD1 net4 iso_B sub! isolbox l=10.0u w=10.0u
* noconn iso_B
XR4 Vss iso_B ptap1 R=[ ev { 1.0 / ( 1.0 / ( 9.8e-10 / ( 0.78e-6 * 0.78e-6 ) ) + 1.0 / ( 9.8e-4 / ( 2.0 * ( 0.78e-6 + 0.78e-6 ) ) ) ) }
+ ] w=0.78e-6 l=0.78e-6
**** begin user architecture code

.lib cornerRES.lib res_typ
.include diodes.lib



.param temp=27
.control
save all
op
echo Silicide resisotr value:
print (Vcc-Vss)/I(Vsil)
echo Unsilicide poly resisotr value:
print (Vcc-Vss)/I(Vppd)
echo High poly resisotr value:
print (Vcc-Vss)/I(Vrh)
reset
dc temp -40 125 1
write iso_dc_res.raw
wrdata iso_dc_res.csv I(Vsil) I(Vppd) I(Vrh)
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL sub!
.end
