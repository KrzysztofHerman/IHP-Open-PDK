** sch_path: ihp-sg13g2/libs.tech/xschem/sg13g2_tests/iso_dc_hv_nmos.sch
* Copyright 2023 IHP PDK Authors
**.subckt iso_dc_hv_nmos
Vgs G S 1.2
Vds D S 1.5
Vd D net1 0
.save i(vd)
XD1 net2 S sub! isolbox l=10.0u w=10.0u
XR1 sub! GND ptap1 R=[ ev { 1.0 / ( 1.0 / ( 9.8e-10 / ( 0.78e-6 * 0.78e-6 ) ) + 1.0 / ( 9.8e-4 / ( 2.0 * ( 0.78e-6 + 0.78e-6 ) ) ) ) }
+ ] w=0.78e-6 l=0.78e-6
XR2 iso_B S ptap1 R=[ ev { 1.0 / ( 1.0 / ( 9.8e-10 / ( 0.78e-6 * 0.78e-6 ) ) + 1.0 / ( 9.8e-4 / ( 2.0 * ( 0.78e-6 + 0.78e-6 ) ) ) ) }
+ ] w=0.78e-6 l=0.78e-6
Vdd net2 GND 3.3
XM1 net1 G S iso_B sg13_hv_nmos w=0.3u l=0.45u ng=1 m=1
**** begin user architecture code
 .lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.include diodes.lib



.include dc_hv_nmos.save
.param temp=27
.control
save all
op
set appendwrite
dc Vds 0 3.3 0.01 Vgs 0.3 3.0 0.1
write iso_dc_hv_nmos.raw
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL sub!
.end
