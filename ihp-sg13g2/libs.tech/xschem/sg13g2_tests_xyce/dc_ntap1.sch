** sch_path: ihp-sg13g2/libs.tech/xschem/sg13g2_tests_xyce/dc_ntap1.sch
* Copyright 2023 IHP PDK Authors
**.subckt dc_ntap1
Vres Vcc GND 1.5
Vr Vcc net1 0
.save i(vr)
XR1 GND net1 ntap1 R=[ ev { 1.0 / ( 1.0 / ( 9.8e-10 / ( 1.78e-6 * 1.78e-6 ) ) + 1.0 / ( 9.8e-4 / ( 2.0 * ( 1.78e-6 + 1.78e-6 ) ) ) ) }
+ ] w=1.78e-6 l=1.78e-6
**** begin user architecture code









.lib cornerRES.lib res_typ






.param temp=27
.control
save all
op
print Vcc/I(Vr)
reset
dc Vres 0 3 0.01
write dc_ntap1.raw
.endc



**** end user architecture code
**.ends
.GLOBAL GND
.end
